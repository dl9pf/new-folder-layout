RDEPENDS_${PN} += "
	agl-service-network-tools \
	"
