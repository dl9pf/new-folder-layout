require ${@bb.utils.contains('DISTRO_FEATURES', 'appfw', 'linux-appfw.inc', '', d)}

