# Add not yet upstreamed patch that enables on target gcov usage
SRC_URI += "file://0001-add-gcov-filter-source-errors-option.patch"
