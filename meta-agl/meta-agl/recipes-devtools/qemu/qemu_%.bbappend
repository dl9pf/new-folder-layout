QEMU_TARGETS_class-target_aglegvirt = " aarch64 x86_64"
