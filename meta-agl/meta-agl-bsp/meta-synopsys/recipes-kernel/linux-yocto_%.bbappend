require recipes-kernel/linux/linux-agl.inc
