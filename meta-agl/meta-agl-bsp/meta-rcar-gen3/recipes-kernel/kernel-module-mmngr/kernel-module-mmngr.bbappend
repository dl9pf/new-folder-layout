KERNEL_MODULE_AUTOLOAD_append = " mmngr"
KERNEL_MODULE_PACKAGE_SUFFIX = ""
