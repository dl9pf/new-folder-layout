KERNEL_MODULE_AUTOLOAD_append = " mmngrbuf"
KERNEL_MODULE_PACKAGE_SUFFIX = ""
