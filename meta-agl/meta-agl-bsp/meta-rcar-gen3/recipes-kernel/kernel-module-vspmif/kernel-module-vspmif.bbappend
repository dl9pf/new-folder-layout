KERNEL_MODULE_AUTOLOAD_append = " vspm_if"
KERNEL_MODULE_PACKAGE_SUFFIX = ""
