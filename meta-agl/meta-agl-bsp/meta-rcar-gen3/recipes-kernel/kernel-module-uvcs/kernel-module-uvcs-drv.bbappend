require checksum_control.inc

KERNEL_MODULE_AUTOLOAD = "uvcs_drv"
