require recipes-kernel/linux/linux-agl-4.14.inc


