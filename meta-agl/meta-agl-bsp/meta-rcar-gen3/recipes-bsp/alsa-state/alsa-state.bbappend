FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

COMPATIBLE_MACHINE = "(salvator-x|m3ulcb|h3ulcb|ebisu)"

PACKAGE_ARCH = "${MACHINE_ARCH}"

