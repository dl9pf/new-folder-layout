FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI +=" \
            file://0001-Remove-redundant-YYLOC-global-declaration.patch \
          "
