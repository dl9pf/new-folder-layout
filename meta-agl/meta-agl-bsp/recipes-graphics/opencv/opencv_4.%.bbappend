FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += " \
        file://0004-Change-Max-Device-Count-To-16.patch \
        "
