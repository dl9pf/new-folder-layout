do_configure_append_bbe() {
    echo 'gbm-format=rgb565' >> ${WORKDIR}/core.cfg
}
