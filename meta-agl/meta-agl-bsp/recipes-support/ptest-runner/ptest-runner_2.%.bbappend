FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0007-WIP-Initial-LAVA-support.patch"

