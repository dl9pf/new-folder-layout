FILESEXTRAPATHS_prepend_dra7xx-evm := "${THISDIR}/${PN}:"
