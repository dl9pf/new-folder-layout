# Disable faad by default to avoid licensing issues
PACKAGECONFIG_remove_rpi = "faad"
