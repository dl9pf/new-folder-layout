RDEPENDS_${PN} += " \
    agl-service-audiomixer \
    bluez-alsa-pipewire \
    "