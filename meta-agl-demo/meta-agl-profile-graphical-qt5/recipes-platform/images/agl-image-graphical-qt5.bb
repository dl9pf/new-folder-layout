SUMMARY = "A very basic Wayland image with a terminal"

require agl-image-graphical-qt5.inc

LICENSE = "MIT"
