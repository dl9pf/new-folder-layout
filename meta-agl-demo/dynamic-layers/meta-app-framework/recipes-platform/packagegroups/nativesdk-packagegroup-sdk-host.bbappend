RDEPENDS_${PN} =+ "nativesdk-low-level-can-generator"

