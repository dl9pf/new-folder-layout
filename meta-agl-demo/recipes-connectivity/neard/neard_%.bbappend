require ${@bb.utils.contains('AGL_FEATURES', 'agldemo', '${BPN}_agl.inc', '', d)}
