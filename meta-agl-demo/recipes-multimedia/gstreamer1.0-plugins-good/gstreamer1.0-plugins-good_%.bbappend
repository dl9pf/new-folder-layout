# libv4l2 is useful for making more efficient use of cameras via v4l2src.
PACKAGECONFIG_append = " libv4l2"
