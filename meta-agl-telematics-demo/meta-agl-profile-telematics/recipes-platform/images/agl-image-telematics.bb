SUMMARY = "A basic telematics image"

require agl-image-telematics.inc

LICENSE = "MIT"

IMAGE_INSTALL_append = "\
    profile-telematics \
    "
