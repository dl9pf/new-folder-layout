PACKAGECONFIG = "wayland-gles2"
PACKAGECONFIG[wayland-gles2] = ",,virtual/egl virtual/libgles2 wayland"
