RDEPENDS_${PN} += "\
	smack-system-setup \
	xmlsec1 \
	cynagora \
	security-manager \
	security-manager-policy \
	agl-users \
    "

