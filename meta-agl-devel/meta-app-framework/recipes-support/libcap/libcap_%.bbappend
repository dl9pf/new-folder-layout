FILESEXTRAPATHS_append_class-native := ":${THISDIR}/${PN}"
# FIXME: It needs to be determined if this is still required
#SRC_URI_append_class-native = " file://removing-capability-enforcement.patch"
