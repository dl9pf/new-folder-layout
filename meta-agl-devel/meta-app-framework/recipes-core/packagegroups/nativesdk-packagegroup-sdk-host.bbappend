RDEPENDS_${PN} =+ "nativesdk-af-main-tools nativesdk-af-binder-devtools"

