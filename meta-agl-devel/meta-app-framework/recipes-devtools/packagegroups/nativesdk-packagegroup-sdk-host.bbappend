RDEPENDS_${PN} += "nativesdk-low-level-can-generator \
		nativesdk-cmake-apps-module \
"
