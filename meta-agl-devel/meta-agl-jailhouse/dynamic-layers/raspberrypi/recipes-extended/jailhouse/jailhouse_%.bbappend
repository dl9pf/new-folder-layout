DEPENDS_append_raspberrypi4 = " trusted-firmware-a"

