KERNEL_MODULE_AUTOLOAD += "mmngrbuf"
KERNEL_MODULE_PROBECONF += "mmngrbuf"
module_conf_mmngrbuf = ""
