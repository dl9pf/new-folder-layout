KERNEL_MODULE_AUTOLOAD = "uvcs_drv"
