COMPATIBLE_HOST_aarch64 = 'aarch64.*-linux'
