require ctemplate.inc

SRC_URI = "git://github.com/svn2github/ctemplate.git"
SRCREV = "9d042b571340e91a75709fc50c03ca086b3121e4"
SRC_URI[md5sum] = ""
SRC_URI[sha256sum] = ""
S = "${WORKDIR}/git"
B = "${WORKDIR}/git"

