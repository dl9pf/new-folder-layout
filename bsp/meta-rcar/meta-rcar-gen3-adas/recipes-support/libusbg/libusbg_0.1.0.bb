require libusbg.inc

S = "${WORKDIR}/git"

SRC_URI = "https://github.com/${BPN}/${BPN}.git"

# tag: v0.1.0
SRCREV = "7e2b04363f319e8936a606bdb122dbde249a2f58"
