require ${PN}.inc

S = "${WORKDIR}/git"

SRC_URI = "git://github.com/stevengj/${BPN}.git"

# tag: nlopt-2.4.2
SRCREV = "355a597b43c80f616252cb370fa9f7e5c997418e"
